# Keil uVision project yap.uvproj, settings and files
target yap (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: Yap +hex
  AfterMake: fromelf.exe --bin -o yap.bin output/yap.axf
  c flags: Optim=1 wLevel=2
  c misc: --gnu
  c include: .\include;.\kernel;.\arch\arm
  asm include: .\inc
  memory RVCT1: ROM 0x30000000 size 0x800000
  memory RVCT6: RAM 0x30800000 size 0xf00000
  memory RVCT9: RAM 0x40000000 size 0x1000
  link misc: --sort=CallTree --entry _start --diag_suppress=L6314
  group source
    ./source/: head.S init_system.c key.c led.c main.c mmu.c
target nor (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: TQ2440_Test +hex
  AfterMake: fromelf.exe --bin -o @p.bin output/@p.axf
  c flags: Optim=1
  c include: .\inc
  asm include: .\inc
  memory RVCT1: ROM 0x0 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x800000
  memory RVCT9: RAM 0x40000000 size 0x1000
  link misc: --sort=CallTree
